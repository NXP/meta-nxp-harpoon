FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Harpoon-2.0.0-release-for-lf-5.10.72-2.2.0.patch"
