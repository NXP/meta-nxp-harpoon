# Copyright (C) 2021-2023 NXP

require harpoon-apps-freertos.inc
require rpmsg-lite-uri.inc

SUMMARY = "Harpoon Application - RT Latency (FreeRTOS)"

HARPOON_APPS_APP = "rt_latency"
HARPOON_APPS_APP_BIN = "rt_latency.bin"
