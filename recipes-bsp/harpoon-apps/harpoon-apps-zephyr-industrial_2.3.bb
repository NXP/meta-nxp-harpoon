# Copyright (C) 2022 NXP

require harpoon-apps-zephyr.inc
require harpoon-apps-zephyr-boards-singlecore.inc

SUMMARY = "Harpoon Application - Industrial (Zephyr)"

HARPOON_APPS_APP = "industrial"
HARPOON_APPS_APP_BIN = "industrial.bin"
