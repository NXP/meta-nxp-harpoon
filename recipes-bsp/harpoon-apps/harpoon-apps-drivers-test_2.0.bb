# Copyright (C) 2021 NXP

require harpoon-apps.inc

SUMMARY = "Harpoon Application - Drivers Test"

HARPOON_APPS_APP = "harpoon_drivers_test"
HARPOON_APPS_APP_BIN = "harpoon_drivers_test.bin"
