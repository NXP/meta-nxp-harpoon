FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-imx8mm_evk_defconfig-run-jh_mmcboot-by-default.patch"
SRC_URI += "file://0002-imx8mn_ddr4_evk_defconfig-run-jh_mmcboot-by-default.patch"
SRC_URI += "file://0003-imx8mn_evk_defconfig-run-jh_mmcboot-by-default.patch"
