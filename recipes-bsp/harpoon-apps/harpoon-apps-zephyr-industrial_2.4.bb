# Copyright (C) 2022-2023 NXP

require harpoon-apps-zephyr.inc
require harpoon-apps-zephyr-boards-singlecore.inc
require rpmsg-lite-uri.inc

SUMMARY = "Harpoon Application - Industrial (Zephyr)"

HARPOON_APPS_APP = "industrial"
HARPOON_APPS_APP_BIN = "industrial.bin"
