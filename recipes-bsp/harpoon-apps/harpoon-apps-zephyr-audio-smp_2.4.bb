# Copyright (C) 2022-2023 NXP

require harpoon-apps-zephyr.inc
require harpoon-apps-zephyr-boards-smp.inc
require rpmsg-lite-uri.inc

SUMMARY = "Harpoon Application - Audio SMP (Zephyr)"

HARPOON_APPS_APP = "audio"
HARPOON_APPS_APP_BIN = "audio_smp.bin"
