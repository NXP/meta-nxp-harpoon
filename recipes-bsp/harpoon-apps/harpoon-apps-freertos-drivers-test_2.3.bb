# Copyright (C) 2021-2022 NXP

require harpoon-apps-freertos.inc

SUMMARY = "Harpoon Application - Drivers Test (FreeRTOS)"

HARPOON_APPS_APP = "harpoon_drivers_test"
HARPOON_APPS_APP_BIN = "harpoon_drivers_test.bin"
