# Copyright (C) 2021 NXP

require harpoon-apps.inc

SUMMARY = "Harpoon Application - Hello World"

HARPOON_APPS_APP = "hello_world"
HARPOON_APPS_APP_BIN = "hello_world.bin"
