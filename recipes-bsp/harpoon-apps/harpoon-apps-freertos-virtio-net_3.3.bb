# Copyright 2023 NXP

require harpoon-apps-freertos.inc
require heterogeneous-multicore.inc

SUMMARY = "Harpoon Application - Virtio NET (FreeRTOS)"

HARPOON_APPS_APP = "virtio_net"
HARPOON_APPS_APP_BIN = "virtio_net.bin"
