# Copyright (C) 2022 NXP

require harpoon-apps-zephyr.inc
require harpoon-apps-zephyr-boards-singlecore.inc

SUMMARY = "Harpoon Application - RT Latency (Zephyr)"

HARPOON_APPS_APP = "rt_latency"
HARPOON_APPS_APP_BIN = "rt_latency.bin"
