# Copyright (C) 2021-2022 NXP

require harpoon-apps-freertos.inc

SUMMARY = "Harpoon Application - Hello World (FreeRTOS)"

HARPOON_APPS_APP = "hello_world"
HARPOON_APPS_APP_BIN = "hello_world.bin"
