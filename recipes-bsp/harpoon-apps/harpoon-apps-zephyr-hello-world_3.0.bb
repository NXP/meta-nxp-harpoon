# Copyright (C) 2023 NXP

require harpoon-apps-zephyr.inc
require harpoon-apps-zephyr-boards-singlecore.inc

SUMMARY = "Harpoon Application - Hello World (Zephyr)"

HARPOON_APPS_APP = "hello_world"
HARPOON_APPS_APP_BIN = "hello_world.bin"
