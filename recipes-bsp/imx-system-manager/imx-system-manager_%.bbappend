FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-devices-MIMX95-Disable-DDR-Auto-Clock-Gating.patch"
