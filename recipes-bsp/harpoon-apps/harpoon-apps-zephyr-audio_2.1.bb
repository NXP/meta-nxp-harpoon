# Copyright (C) 2022 NXP

require harpoon-apps-zephyr.inc

SUMMARY = "Harpoon Application - Audio (Zephyr)"

HARPOON_APPS_APP = "audio"
HARPOON_APPS_APP_BIN = "audio.bin"
