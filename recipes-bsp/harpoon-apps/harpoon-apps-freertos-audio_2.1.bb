# Copyright (C) 2021-2022 NXP

require harpoon-apps-freertos.inc

SUMMARY = "Harpoon Application - Audio (FreeRTOS)"

HARPOON_APPS_APP = "audio"
HARPOON_APPS_APP_BIN = "audio.bin"
