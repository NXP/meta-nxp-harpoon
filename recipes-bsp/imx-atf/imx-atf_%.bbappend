FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-remove-uart4-from-m7.patch"
SRC_URI += "file://0001-imx8mm-remove-uart4-from-m7.patch"
