FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Harpoon-2.0.0-release-for-Real-Time-Edge-v2.1.patch"
