# Copyright (C) 2021-2022 NXP

require harpoon-apps-freertos.inc

SUMMARY = "Harpoon Application - RT Latency (FreeRTOS)"

HARPOON_APPS_APP = "rt_latency"
HARPOON_APPS_APP_BIN = "rt_latency.bin"
