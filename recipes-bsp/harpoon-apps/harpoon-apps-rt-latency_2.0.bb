# Copyright (C) 2021 NXP

require harpoon-apps.inc

SUMMARY = "Harpoon Application - RT Latency"

HARPOON_APPS_APP = "rt_latency"
HARPOON_APPS_APP_BIN = "rt_latency.bin"
